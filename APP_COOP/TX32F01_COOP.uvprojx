# Keil uVision project TX32F01_COOP.uvprojx, settings and files
target COOP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TX32F01 Generic
  pack: Keil.TX32F01.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x01000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TX32F01_COOP
  AfterMake: fromelf --bin --output ".\Objects\firmware.bin" ".\Objects\TX32F01_COOP.axf"
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Device\CMSIS\KEIL_CORE;..\Device\TX32F01\Include;..\Device\TX32F01\HAL_lib\inc;.\COOP;..\APP_PATCH
  library: MicroLIB
  memory RVCT4: ROM 0x1002000 size 0x5800
  memory RVCT9: RAM 0x20000060 size 0xFA0
  scatter file: .\TX32F01_COOP.sct
  group startup
    ../Device/TX32F01/Source/ARM/: startup_TX32F01.s
  group USER
    ./USER/: main.c
  group COOP
    ./COOP/: coop_sched.c
  group BOOT_GLUE
    ../APP_PATCH/: app_softvec.c
  group HAL
    ../Device/TX32F01/HAL_lib/src/: HAL_SCU.c HAL_GPIO.c HAL_UART.c HAL_Flash.c
