# Keil uVision project TX32F01.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TX32F01 Generic
  pack: Keil.TX32F01.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x01000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TX32F01 +hex
  AfterMake: fromelf --cad !L  --output BootLoader.txt
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\Device\CMSIS\KEIL_CORE;..\..\..\Device\TX32F01\Include;..\..\..\Device\TX32F01\HAL_lib\inc;.\SYSTEM\SYSTICK;.\HARDWARE\Flash;.\HARDWARE\I2C
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ../../../Device/TX32F01/Source/ARM/: startup_TX32F01.s
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/Flash/: flash.c
    ./HARDWARE/I2C/: i2c.c
  group SYSTEM
    ./SYSTEM/SYSTICK/: systick.c
  group HALlib
    ../../../Device/TX32F01/HAL_lib/src/: HAL_Flash.c HAL_GPIO.c HAL_SCU.c HAL_UART.c
