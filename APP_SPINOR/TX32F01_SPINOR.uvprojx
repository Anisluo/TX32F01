# Keil uVision project TX32F01_SPINOR.uvprojx, settings and files
target APP_SPINOR (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TX32F01 Generic
  pack: Keil.TX32F01.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x01000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TX32F01_SPINOR
  AfterMake: fromelf --bin --output ".\Objects\firmware.bin" ".\Objects\TX32F01_SPINOR.axf"
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Device\CMSIS\KEIL_CORE;..\Device\TX32F01\Include;..\Device\TX32F01\HAL_lib\inc;.\SPINOR;.\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\TX32F01_SPINOR.sct
  group startup
    ../Device/TX32F01/Source/ARM/: startup_TX32F01.s
  group USER
    ./USER/: main.c
  group SPINOR
    ./SPINOR/: spinor_emu.c spinor_storage.c
  group BSP
    ./BSP/: bsp_spi_slave.c bsp_uart.c
  group HAL
    ../Device/TX32F01/HAL_lib/src/: HAL_SCU.c HAL_GPIO.c HAL_UART.c HAL_SPI.c HAL_Flash.c
