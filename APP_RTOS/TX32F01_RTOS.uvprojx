# Keil uVision project TX32F01_RTOS.uvprojx, settings and files
target RTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TX32F01 Generic
  pack: Keil.TX32F01.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x01000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TX32F01_RTOS +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Device\CMSIS\KEIL_CORE;..\Device\TX32F01\Include;..\Device\TX32F01\HAL_lib\inc;.\USER;..\3rdparty\FreeRTOS-Kernel\include;..\3rdparty\FreeRTOS-Kernel\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\TX32F01_RTOS.sct
  group startup
    ../Device/TX32F01/Source/ARM/: startup_TX32F01.s
  group USER
    ./USER/: main.c FreeRTOSConfig.h
  group FreeRTOS
    ../3rdparty/FreeRTOS-Kernel/: tasks.c queue.c list.c
    ../3rdparty/FreeRTOS-Kernel/portable/RVDS/ARM_CM0/: port.c
  group HAL
    ../Device/TX32F01/HAL_lib/src/: HAL_SCU.c HAL_GPIO.c HAL_UART.c
